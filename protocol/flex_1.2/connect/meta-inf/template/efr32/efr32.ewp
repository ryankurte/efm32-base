# IAR project efr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SOURCEFILE__="$FILE_FNAME$"; $--bootloader--$; $--partNumber--$; $--chipFamily;U--$
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$\platform\$--deviceDir--$\SiliconLabs-Restricted\$--chipFamily;U--$\Include; $--stackDirFromProjBs--$\platform\$--deviceDir--$\SiliconLabs\$--chipFamily;U--$\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  postbuild: $--deviceName--$-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$'
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=$--flashSize--$; RAM_SIZE=$--ramSize--$; $--bootloader--$=1
  ILINK.IlinkIcfFile: $--linkerIcfFile--$
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    $--stackDirFromProjBs--$/platform/$--deviceDir--$/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
