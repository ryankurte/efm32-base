# IAR project ezr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EZR32LG330F256R60 SiliconLaboratories EZR32LG330F256R60
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SOURCEFILE__="$FILE_FNAME$"; $--bootloader--$
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SOURCEFILE__="$FILE_FNAME$"; $--bootloader--$
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: BTL_SIZE=0K; $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjFs--$/micro/cortexm3/efm32/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
