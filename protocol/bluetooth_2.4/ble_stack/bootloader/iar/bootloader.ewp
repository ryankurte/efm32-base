# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG1P233F256GM48 SiliconLaboratories EFR32BG1P233F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32BG1B232F256GM48; UART_DFU
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\inc\common; ..\..\inc\soc; ..\..\include\common; ..\..\include\soc; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\nvm\inc; ..\..\..\..\..\platform\emdrv\nvm\config; ..\..\..\..\..\platform\Device\SiliconLabs\EFR32BG1B\Include; ..\..\..\..\..\platform\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  postbuild: arm-none-eabi-as -mthumb -mcpu=cortex-m4 -march=armv7e-m ..\binbootloader.S -I $EXE_DIR$ -o $EXE_DIR$\binbootloader.o
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32BG1B232F256GM48; UART_DFU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../: aat.h aat_def.h boot.c boot.h config.h crc.c crc.h dfu.c dfu.h flash.c flash.h main.c main.h uart.c uart.h uart_config.h
    ../../../../../platform/emlib/src/: em_cmu.c em_emu.c em_gpio.c em_system.c em_usart.c
    ../api/: gecko_bgapi.h
    ../../../../../platform/Device/SiliconLabs/EFR32BG1P/Source/: system_efr32bg1p.c
